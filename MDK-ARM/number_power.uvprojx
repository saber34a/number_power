# Keil uVision project number_power.uvprojx, settings and files
target number_power (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801BFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: number_power
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../BSP/ili9341;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x3007c000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c crc.c dma.c i2c.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_crc.c stm32g4xx_hal_crc_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group BSP
    ../BSP/ili9341/: fonts.c ili9341.c ili9341_touch.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
